<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Matrix XR.ewp</path>
    <scc>
      <projname>$/01.Projects/01.Console/Matrix XR/05.Software</projname>
      <auxprojpath></auxprojpath>
    </scc>
  </project>
  <batchBuild/>
</workspace>


