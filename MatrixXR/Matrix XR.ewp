# IAR project Matrix XR.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: EFM32LG380F256 EnergyMicro EFM32LG380F256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: EFM32LG380F256; BSP_CORTEX_EFM32
  ICCARM.CCIncludePath2: ; Local; Modules; Modules\Utilities_Lib; Modules\HAL_Lib; Modules\SPI_Flash_Lib; Modules\LCB_Lib; Modules\Eng_lib; ..\Modules\Eng_lib; Modules\SystemConfig_Lib; Modules\EFM32_lib; Modules\EFM32_lib\drivers; Modules\Program_lib; Modules\RF_lib; Modules\USB_lib; Modules\USB_lib\usb\src; Modules\USB_lib\usb\inc; Modules\WiFi_lib; Modules\EFM32_lib\Include; Modules\EFM32_lib\emlib\inc; Modules\EFM32_lib\emlib\src; Modules\EFM32_lib\drivers\fatfs\src; Modules\EFM32_lib\Device\EnergyMicro\EFM32LG\Include; Modules\EFM32_lib\Device\EnergyMicro\EFM32LG\Source; Modules\EFM32_lib\Device\EnergyMicro\EFM32LG\Source\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Matrix XR V7.020.bin
  ILINK.IlinkOutputFile: Matrix XR.out
  ILINK.IlinkIcfFile: EM_General_APP.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ; Local; Modules; Modules\Utilities_Lib; Modules\HAL_Lib; Modules\LCB_Lib; Modules\SystemConfig_Lib; Modules\EFM32_lib; Modules\EFM32_lib\drivers; Modules\Program_lib; Modules\RF_lib; Modules\USB_lib; Modules\USB_lib\inc; Modules\WiFi_lib; Modules\EFM32_lib\Include; Modules\EFM32_lib\emlib\inc; Modules\EFM32_lib\emlib\src; Modules\EFM32_lib\drivers\fatfs\src; Modules\EFM32_lib\Device\EnergyMicro\EFM32LG\Include; Modules\EFM32_lib\Device\EnergyMicro\EFM32LG\Source; Modules\EFM32_lib\Device\EnergyMicro\EFM32LG\Source\IAR
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: Matrix XR.srec
  group Local
    Local/: Auto_Model.c Display.c Events_Handler.c main.c Page.c Show.c Show_Functions.c Strings.c User.c
  group Local/INC
    Local/: Auto_Model.h Display.h Events_Handler.h LetterCodeTable.h Main.h page.h Show.h Show_Functions.h Strings.h User.h
  group Modules/CMSIS
    Modules/EFM32_lib/Device/EnergyMicro/EFM32LG/Source/IAR/: startup_efm32lg.s
    Modules/EFM32_lib/Device/EnergyMicro/EFM32LG/Source/: system_efm32lg.c
  group Modules/EFM32_lib
    Modules/EFM32_lib/emlib/_src/: em_acmp.c em_adc.c em_aes.c em_assert.c em_burtc.c em_cmu.c em_dac.c em_dbg.c em_dma.c em_ebi.c em_emu.c em_gpio.c em_i2c.c em_int.c em_lcd.c em_lesense.c em_letimer.c em_leuart.c em_mpu.c em_msc.c em_opamp.c em_pcnt.c em_prs.c em_rmu.c em_rtc.c em_system.c em_timer.c em_usart.c em_vcmp.c em_wdog.c
  group Modules/Eng_Lib
    Modules/Eng_lib/: Engmode.c
  group Modules/Eng_Lib/INC
    Modules/Eng_lib/: Engmode.h Engmode_Inner.h
  group Modules/HAL_Lib
    Modules/HAL_Lib/: HAL_Lib.c HT16CXX.c
  group Modules/HAL_Lib/HAL_INC
    Modules/HAL_Lib/: HAL_IO_define.h HAL_Lib.h HT16CXX.h Interrupt_List.h JIStypes.h
  group Modules/LCB_Lib
    Modules/LCB_Lib/: Digital_CMD.c LCB.c
  group Modules/LCB_Lib/LACB_INC
    Modules/LCB_Lib/: Digital_CMD.h LCB.h
  group Modules/Program_Lib
    Modules/Program_lib/: Data_Process.c Pro_constant.c Pro_goals.c Pro_hrc.c Pro_manual.c Pro_table.c Programs.c ProSprint8.c
  group Modules/Program_Lib/PRG_INC
    Modules/Program_lib/: Data_Process.h Pro_constant.h Pro_goals.h Pro_hrc.h Pro_manual.h Pro_table.h Program_Inner.h Programs.h Setting_Config.h Table_List.h WattsTable.h
  group Modules/RF_Lib
    Modules/RF_lib/: CC1100_CC2500.c CC_SPI.c RF_AP.c
  group Modules/RF_Lib/RF_INC
    Modules/RF_lib/: CC1100_CC2500.h CC1100_CC2500_Definition.h CC_SPI.h RF_Lib.h
  group Modules/SPI_Flash_Lib
    Modules/SPI_Flash_Lib/: EEPROM_Langauge.c SPI_Flash.c
  group Modules/SPI_Flash_Lib/INC
    Modules/SPI_Flash_Lib/: EEPRom_Language.h SPI_Flash.h
  group Modules/SystemConfig_Lib
    Modules/SystemConfig_Lib/: SystemConfig.c
  group Modules/SystemConfig_Lib/SYS_INC
    Modules/SystemConfig_Lib/: FACTORYDEFAULT.H global_config.h jisdef.h SystemConfig.h
  group Modules/USB_Lib
    Modules/USB_lib/usb/src/: em_usbd.c em_usbdch9.c em_usbdep.c em_usbdint.c em_usbh.c em_usbhal.c em_usbhep.c em_usbhint.c em_usbtimer.c
    Modules/USB_lib/: USBManager.c
  group Modules/USB_Lib/drivers
    Modules/USB_lib/drivers/: msdbot.c msdh.c msdscsi.c
  group Modules/USB_Lib/INC
    Modules/USB_lib/: usbconfig.h USBManager.h
  group Modules/USB_Lib/usb/inc
    Modules/USB_lib/drivers/fatfs/src/: diskio.h ff.h ffconf.h integer.h
  group Modules/USB_Lib/usb/src
    Modules/USB_lib/drivers/fatfs/src/option/: ccsbcs.c
    Modules/USB_lib/drivers/fatfs/src/: ff.c msddiskio.c
  group Modules/UTL_Lib
    Modules/Utilities_Lib/: Midware_Heart_01.c UtilitiesAMP.c UtilitiesBeep.c UtilitiesBor.c UtilitiesBurntest.c UtilitiesErp.c UtilitiesErrorcode.c UtilitiesFan.c UtilitiesKeyboard.c UtilitiesLubeBelt.c UtilitiesRtc.c UtilitiesTimer.c
  group Modules/UTL_Lib/UTL_INC
    Modules/Utilities_Lib/: Midware_Heart.h UtilitiesAMP.h UtilitiesBeep.h UtilitiesBor.h UtilitiesBurntest.h UtilitiesErp.h UtilitiesErrorcode.h UtilitiesFan.h UtilitiesHeart.h UtilitiesKeyboard.h UtilitiesKeyInputMethod.h UtilitiesLubeBelt.h UtilitiesProcess.h UtilitiesRtc.h UtilitiesTimer.h UtilitiesUserEdit.h
  group Modules/WiFi_Lib
    Modules/WiFi_lib/: CRC.c Digital_wifi.c wifi_event_handlers.c wifi_interface.c
  group Modules/WiFi_Lib/WIFI_INC
    Modules/WiFi_lib/: CRC.h Digital_wifi.h MyStruct.H system_config.h wifi_api.h wifi_event_handlers.h wifi_interface.h WiFiTest.h
